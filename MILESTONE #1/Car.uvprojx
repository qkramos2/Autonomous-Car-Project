# Keil uVision project Car.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM Compiler 5)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source Group 1
    ./: ADC14.c Bluetooth.c CAR.c Camera.c ControlPins.c CortexM.c DCMotors.c I2C.c LEDs.c OLED.c PID.c ServoMotor.c Switches.c SysTickTimer.c Timer32.c TimerA.c UART.c ADC14.h Bluetooth.h Camera.h Common.h ControlPins.h CortexM.h DCMotors.h I2C.h LEDs.h OLED.h PID.h ServoMotor.h Switches.h SysTickTimer.h Timer32.h TimerA.h UART.h FontPack.h
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.2
